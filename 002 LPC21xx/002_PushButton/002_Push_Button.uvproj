# Keil uVision project 002_Push_Button.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 002_Push_Button +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c clock.c clock.h gpio.c gpio.h eIrq.c eIrq.h led.c
