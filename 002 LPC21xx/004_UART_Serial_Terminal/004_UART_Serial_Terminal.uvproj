# Keil uVision project 004_UART_Serial_Terminal.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 004_UART_Serial_Terminal +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s clock.c gpio.c main.c uart.c clock.h gpio.h uart.h timer.c timer.h
